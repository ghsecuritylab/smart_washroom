# Keil uVision project SmartWashroom_Prj.uvprojx, settings and files
target STM32_BD_F429_V01 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartWashroomxx_Prj +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,
  c misc: --C99
  c include: ../../../Utilities/cpu;../../../Utilities/common/inc;../../../Bsp/ST_Driver/CMSIS/Include;../../../Bsp/ST_Driver/STM32F4xx_HAL_Driver/Inc;../../../Bsp/ST_Driver/board/maserati_F429/Config;../../../Bsp/ST_Driver/board/maserati_F429/STM32_BD_F429_V01/inc;../../../Bsp/ST_Driver/CMSIS/Device/ST/STM32F4xx/Include;../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../Middlewares/Third_Party/FatFs/src/drivers;../../../Middlewares/Third_Party/FatFs/src;../../../Middlewares/ST/STemWin/inc;../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../App/Config;../../../App/App/Inc;../../../Hal/inc;../../../Biz/inc;../../../App/Modules;../../../Bsp/Components/at070tn92;../../../Utilities/Log;../../../Utilities/uboot/cli/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App/App
    ../../../App/App/Src/: main.c app_main.c
    ../../../App/Config/: app_config.h
  group Biz
    ../../../Biz/src/: biz_init.c
  group Hal
    ../../../Hal/src/: hal_init.c hal_led.c hal_sdram.c hal_lcd.c hal_mem.c hal_touch.c hal_sw_i2c.c hal_uart.c
  group Bsp/ST_Drivers/board/maserati_F429/dev
    ../../../Bsp/ST_Driver/board/maserati_F429/STM32_BD_F429_V01/src/: bsp_dev_init.c bsp_dev_led.c bsp_dev_sdram.c bsp_dev_lcd_config.c bsp_dev_lcd_ewin.c bsp_dev_key.c bsp_dev_i2c_gpio.c
  group Bsp/ST_Drivers/board/maserati_F429/mcu
    ../../../Bsp/ST_Driver/board/maserati_F429/STM32_BD_F429_V01/src/: bsp_mcu_uart.c
  group Bsp/ST_Drivers/CMSIS
    ../../../Bsp/ST_Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group Bsp/ST_Drivers/STM32F4xx_HAL_Drivers
    ../../../Bsp/ST_Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group Bsp/ST_Drivers/Bsp/Config
    ../../../Bsp/ST_Driver/board/maserati_F429/Config/: STM32_BD_F429_V01.h stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_conf.h
  group Mid/FreeRTOS
    ../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Mid/FreeRTOS/Portable
    ../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Mid/STemWin/Library
    ../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM4_OS_Keil.lib
  group Mid/STemWin/OS
    ../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Mid/STemWin/Config
    ../../../App/Config/: GUIConf.c LCDConf.c
  group Utilities/common
    ../../../Utilities/CPU/: cpu_utils.c
    ../../../Utilities/common/inc/: common_def.h common_all_macro_def.h
  group Utilities/log
    ../../../Utilities/Log/: serial_debug_log.c
  group Doc
    ../../../Doc/: 01 doc_version.txt 02 doc_project_info.txt 03.STM32_BD_F429_V01_GPIO分配表(按GPIO次序排列).txt 04.STM32_BD_F429_V01_GPIO分配表(按功能排列).txt
